# Keil uVision project 模板.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 模板 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD  USE_STDPERIPH_DRIVER
  c include: ..\Lib\inc;..\User;..\Startup;..\Usart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Startup/: core_cm3.c startup_stm32f10x_hd.s
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c extigroup.c delay.c stm32_clock.c led.c pwm.c key.c wave.c
    ../Usart/: usart.c
  group Lib
    ../Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dac.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_exti.c
software components: CMSIS:CORE 5.0.0
